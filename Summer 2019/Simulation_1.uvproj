# Keil uVision project Simulation_1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: Simulation_1
  c flags: Optim=1
  group Source Group 1
    ./: main.c
    ./STM32F2xx_StdPeriph_Lib_V1.1.0-master/STM32F2xx_StdPeriph_Lib_V1.1.0-master/Libraries/STM32F2xx_StdPeriph_Driver/inc/: stm32f2xx_gpio.h
